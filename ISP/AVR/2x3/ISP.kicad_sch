File: ISP/AVR/2x3/ISP.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: Fix grid alignment and update to KiCad 9
