File: ISP/AVR/TP/ISP.kicad_sch (KiCad schematic)
At the start: 6 parts

Commit message: Fix grid alignment and update to KiCad 9
